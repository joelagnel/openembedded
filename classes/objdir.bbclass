do_configure[dirs] += "${B}"
do_compile[dirs] += "${B}"
do_install[dirs] += "${B}"
do_populate_sysroot[dirs] += "${B}"
